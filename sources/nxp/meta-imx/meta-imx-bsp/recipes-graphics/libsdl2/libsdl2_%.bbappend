PACKAGECONFIG:append = " ${PACKAGECONFIG_LIBDECOR}"
PACKAGECONFIG_LIBDECOR ??= "libdecor"
