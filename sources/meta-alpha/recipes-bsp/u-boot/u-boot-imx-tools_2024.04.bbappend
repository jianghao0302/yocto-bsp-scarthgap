LICENSE = "CLOSED"
LIC_FILES_CHKSUM = ""

UBOOT_SRC = "git://github.com/jianghao0302/uboot-imx.git;protocol=https"
SRCBRANCH = "master"
SRCREV = "${AUTOREV}"