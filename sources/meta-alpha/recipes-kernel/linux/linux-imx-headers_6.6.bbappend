LICENSE = "CLOSED"
LIC_FILES_CHKSUM = ""

LINUX_IMX_SRC = "git://github.com/jianghao0302/linux-imx.git;protocol=https;branch=master"
SRCREV = "${AUTOREV}"
